# IAR project tls_demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: FTFS_API_VERSION=100; APPCONFIG_DEBUG_ENABLE=1; NO_FILESYSTEM=1; NDEBUG=1; NO_PSK=1; NO_DEV_RANDOM=1; FREERTOS=1; CYASSL_LWIP=1; MC200_AES_HW_ACCL=1
  ICCARM.PreInclude: ..\..\..\..\..\bin\wmsdk-iar\incl\autoconf.h
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\CMSIS\Include; ..\..\..\..\..\bin\wmsdk-iar\incl\sdk; ..\..\..\..\..\bin\wmsdk-iar\incl\sdk\drivers; ..\..\..\..\..\bin\wmsdk-iar\incl\sdk\drivers\wlan; ..\..\..\..\..\bin\wmsdk-iar\incl\sdk\drivers\mc200; ..\..\..\..\..\bin\wmsdk-iar\incl\sdk\drivers\mc200\regs; ..\..\..\..\..\bin\wmsdk-iar\incl\platform\os\freertos; ..\..\..\..\..\bin\wmsdk-iar\incl\platform\arch\; ..\..\..\..\..\bin\wmsdk-iar\incl\platform\net\lwip\; ..\..\..\..\..\bin\wmsdk-iar\incl\freertos\; ..\..\..\..\..\bin\wmsdk-iar\incl\cyassl\; ..\..\..\..\..\bin\wmsdk-iar\incl\cyassl\ctaocrypt\; ..\..\..\..\..\bin\wmsdk-iar\incl\lwip\; ..\..\..\..\..\bin\wmsdk-iar\incl\libc\; ..\..\..\..\..\bin\wmsdk-iar\incl\lwip\ipv4\; ..\; ..\..\..\..\..\bin\wmsdk-iar\incl\cyassl\; ..\..\..\..\..\bin\wmsdk-iar\incl\cyassl\ctaocrypt\; ..\..\..\..\..\bin\wmsdk-iar\incl\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: tls_demo.bin
  ILINK.IlinkOutputFile: tls_demo.out
  ILINK.IlinkIcfFile: ..\..\..\..\toolchains\iar\mc200.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\bin\wmsdk-iar\libs\libapp_framework.a; ..\..\..\..\..\bin\wmsdk-iar\libs\libarch.a; ..\..\..\..\..\bin\wmsdk-iar\libs\libc.a; ..\..\..\..\..\bin\wmsdk-iar\libs\libcli.a; ..\..\..\..\..\bin\wmsdk-iar\libs\libcyassl.a; ..\..\..\..\..\bin\wmsdk-iar\libs\libdhcpd.a; ..\..\..\..\..\bin\wmsdk-iar\libs\libdiagnostics.a; ..\..\..\..\..\bin\wmsdk-iar\libs\libdrv.a; ..\..\..\..\..\bin\wmsdk-iar\libs\libdtp.a; ..\..\..\..\..\bin\wmsdk-iar\libs\libezxml.a; ..\..\..\..\..\bin\wmsdk-iar\libs\libfreertos.a; ..\..\..\..\..\bin\wmsdk-iar\libs\libftfs.a; ..\..\..\..\..\bin\wmsdk-iar\libs\libhealthmon.a; ..\..\..\..\..\bin\wmsdk-iar\libs\libhttpclient.a; ..\..\..\..\..\bin\wmsdk-iar\libs\libhttpd.a; ..\..\..\..\..\bin\wmsdk-iar\libs\libjson.a; ..\..\..\..\..\bin\wmsdk-iar\libs\liblcd.a; ..\..\..\..\..\bin\wmsdk-iar\libs\liblwip.a; ..\..\..\..\..\bin\wmsdk-iar\libs\libmdev.a; ..\..\..\..\..\bin\wmsdk-iar\libs\libmdns.a; ..\..\..\..\..\bin\wmsdk-iar\libs\libmrvlcrypto.a; ..\..\..\..\..\bin\wmsdk-iar\libs\libnet.a; ..\..\..\..\..\bin\wmsdk-iar\libs\libos.a; ..\..\..\..\..\bin\wmsdk-iar\libs\liboverlays.a; ..\..\..\..\..\bin\wmsdk-iar\libs\libpart.a; ..\..\..\..\..\bin\wmsdk-iar\libs\libprovisioning.a; ..\..\..\..\..\bin\wmsdk-iar\libs\libpsm.a; ..\..\..\..\..\bin\wmsdk-iar\libs\libpwrmgr.a; ..\..\..\..\..\bin\wmsdk-iar\libs\librfget.a; ..\..\..\..\..\bin\wmsdk-iar\libs\libsysinfo.a; ..\..\..\..\..\bin\wmsdk-iar\libs\libtelnetd.a; ..\..\..\..\..\bin\wmsdk-iar\libs\libtls.a; ..\..\..\..\..\bin\wmsdk-iar\libs\libttcp.a; ..\..\..\..\..\bin\wmsdk-iar\libs\libutil.a; ..\..\..\..\..\bin\wmsdk-iar\libs\libwifidriver.a; ..\..\..\..\..\bin\wmsdk-iar\libs\libwlcmgr.a; ..\..\..\..\..\bin\wmsdk-iar\libs\libwmcrypto.a; ..\..\..\..\..\bin\wmsdk-iar\libs\libwmstdio.a; ..\..\..\..\..\bin\wmsdk-iar\libs\libwmtime.a; ..\..\..\..\..\bin\wmsdk-iar\libs\libwps.a; ..\..\..\..\..\bin\wmsdk-iar\libs\libxflash.a; ..\..\..\..\..\bin\wmsdk-iar\libs\libxz.a
  ILINK.IlinkProgramEntryLabel: Reset_IRQHandler
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: wmsdk_iar.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../: board.c led_indicator.c main.c mdns_helper.c reset_prov_helper.c tls-demo.c tls-httpc.c wps_helper.c
    ../../../../toolchains/iar/: mc200_iar.c

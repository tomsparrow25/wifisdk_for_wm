<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\module_demo\cli_demo\src\iar\cli_demo.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\io_demo\gpio\src\iar\gpio.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\helloworld\src\iar\helloworld.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\io_demo\i2c\i2c_master_demo\src\iar\i2c_master_demo.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\io_demo\i2c\i2c_slave_demo\src\iar\i2c_slave_demo.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\pm_demo\pm_i2c_master\src\iar\pm_i2c_master.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\pm_demo\pm_i2c_slave\src\iar\pm_i2c_slave.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\module_demo\psm_demo\src\iar\psm_demo.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\io_demo\ssp\ssp_full_duplex_demo\src\iar\ssp_full_duplex_demo.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\io_demo\ssp\ssp_master_demo\src\iar\ssp_master_demo.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\io_demo\ssp\ssp_slave_demo\src\iar\ssp_slave_demo.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\module_demo\tls_demo\src\iar\tls_demo.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\io_demo\uart\uart_dma_rx_demo\src\iar\uart_dma_rx_demo.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\io_demo\uart\uart_dma_tx_demo\src\iar\uart_dma_tx_demo.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\io_demo\uart\uart_echo_demo\src\iar\uart_echo_demo.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\wlan\wlan_prov\src\iar\wlan_prov.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\wlan\wlan_uap\src\iar\wlan_uap.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\wlan\wm_demo\src\iar\wm_demo.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\wlan\wpa2_enterprise\src\iar\wpa2_enterprise.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>wmsdk_iar</name>
      <member>
        <project>cli_demo</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>gpio</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>helloworld</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>i2c_master_demo</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>i2c_slave_demo</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>pm_i2c_master</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>pm_i2c_slave</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>psm_demo</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>ssp_full_duplex_demo</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>ssp_master_demo</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>ssp_slave_demo</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>uart_dma_rx_demo</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>uart_dma_tx_demo</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>uart_echo_demo</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>wlan_prov</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>wlan_uap</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>wm_demo</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


